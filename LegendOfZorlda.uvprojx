# Keil uVision project LegendOfZorlda.uvprojx, settings and files
target LegendOfZorlda (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LegendOfZorlda
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --C99
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ADC.c ADC.h DAC.c DAC.h Images.h LCD.h LCD.s LegendOfZorlda.c Print.s random.h random.s Sound.c Sound.h startup.s Timer0.c Timer0.h Timer1.c Timer1.h ST7735.c entity.h player.h stage.h entity.c player.c stage.c Images.c music.c music.h proj.c rupoo.c item.c zStructs.h
  group ObjectCode
    ./: texas.o
software components: CMSIS:CORE 5.3.0
